hostname = "agh-socfpga"
