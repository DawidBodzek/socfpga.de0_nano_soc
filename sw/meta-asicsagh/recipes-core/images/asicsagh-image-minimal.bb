require recipes-core/images/core-image-minimal.bb
require recipes-core/images/include/asicsagh-image.inc

export IMAGE_BASENAME = "asicsagh-image-minimal"
