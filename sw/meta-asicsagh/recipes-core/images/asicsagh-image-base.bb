require recipes-core/images/core-image-base.bb
require recipes-core/images/include/asicsagh-image.inc

export IMAGE_BASENAME = "asicsagh-image-base"
